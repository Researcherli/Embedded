# Keil uVision project FreeRTOS-temp.uvprojx, settings and files
target FreeRTOS-temp (6240000::V6.24::ARMCLANG)
  device: GD32F450II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS-temp
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_USB_FS, GD32F450, HXTAL_VALUE = 24000000
  c include: ..\..\User;..\..\User\init;..\..\task;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Firmware\GD32F4xx_periph\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\ARM_CM4F;..\..\USB_Library\driver\Include;..\..\USB_Library\device\core\Include;..\..\USB_Library\device\class\cdc\Include;..\..\USB_Library\ustd\common;..\..\USB_Library\ustd\class\cdc
  asm include: ..\..\User;..\..\User\init;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Firmware\GD32F4xx_periph\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c gd32f4xx_it.c FreeRTOSConfig.h
  group Init
    ../../User/init/: gd32f4xx_hw.c usb_init.c
  group Task
    ../../task/: usb_task.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable/ARM_CM4F
    ../../FreeRTOS/portable/ARM_CM4F/: port.c
  group FreeRTOS/portable/MemMang
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Firmware/CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Firmware/GD32F4xx_periph
    ../../Firmware/GD32F4xx_periph/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group USB_Library
    ../../USB_Library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../../USB_Library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../../USB_Library/device/class/cdc/Source/: cdc_acm_core.c
