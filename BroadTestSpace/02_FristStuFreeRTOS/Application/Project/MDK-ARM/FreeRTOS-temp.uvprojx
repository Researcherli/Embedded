# Keil uVision project FreeRTOS-temp.uvprojx, settings and files
target GD32F450_APP (6240000::V6.24::ARMCLANG)
  device: GD32F450II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS-temp +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=..\build\Objects\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: GD32F450,USE_USB_FS,HXTAL_VALUE=24000000
  c include: ..\..\Application\INC;..\..\Application\SRC;..\..\Application\TASK;..\..\BSP;..\..\Drivers\CMSIS;..\..\Drivers\CMSIS\GD;..\..\Drivers\CMSIS\GD\GD32F4xx;..\..\Drivers\CMSIS\GD\GD32F4xx\Include;..\..\Drivers\CMSIS\GD\GD32F4xx\Source;..\..\Drivers\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Middlewares\FreeRTOS;..\..\Drivers\FWLIB\Include;..\..\Middlewares\USB;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\MemMang;..\..\Middlewares\FreeRTOS\GCC\ARM_CM4F;..\..\Middlewares;..\..\Middlewares\USB\inc;..\..\Middlewares\USB\GD32F4xx_usb_library\driver\Include;..\..\Middlewares\USB\GD32F4xx_usb_library\device\core\Include;..\..\Middlewares\USB\GD32F4xx_usb_library\device\class\cdc\Include;..\..\Middlewares\USB\GD32F4xx_usb_library\ustd\common;..\..\Middlewares\USB\GD32F4xx_usb_library\ustd\class\cdc;..\..\..\Common\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: FreeRTOS-temp.sct
  group Common
    ../../../Common/Inc/: boot_partition.h boot_param.h
  group Application/INC
    ../../Application/INC/: FreeRTOSConfig.h gd32f4xx_it.h systick.h device.h
  group Application/SRC
    ../../Application/SRC/: gd32f4xx_it.c main.c systick.c
  group Application/TASK
    ../../Application/TASK/: usb_task.c usb_task.h
  group BSP
    ../../BSP/: bsp_uart.c
  group Middlewares/FreeRTOS
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/GCC/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/: core_cm4.h gd32f4xx_libopt.h
    ../../Drivers/CMSIS/GD/GD32F4xx/Include/: gd32f4xx.h system_gd32f4xx.h
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Drivers/FWLIB
    ../../Drivers/FWLIB/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/GD32F4xx_usb_library/device/class/cdc/Source/: cdc_acm_core.c
  group Middlewares/USB_DEVICE
    ../../Middlewares/USB/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group Middlewares/USB_DRIVERS
    ../../Middlewares/USB/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../../Middlewares/USB/: usb_driver.c
